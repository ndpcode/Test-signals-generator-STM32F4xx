# Keil uVision project generator407.uvprojx, settings and files
target generator407 (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: generator407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers\GPIO;..\Drivers\MT12864;..\Drivers\MENU;..\Drivers\MENU\MenuItems;..\Drivers\UniGraphic;..\Drivers\AD9850;..\Drivers\PatternGenerator;..\Drivers\StandardSignalGenerator;..\Drivers\PatternGenerator\SimpleGenerator;..\Drivers\FrequencyMeter;..\Drivers\Gen_Flash;..\Drivers\spi_eeprom
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Core/Src/: main.c rtc.c stm32f4xx_it.c stm32f4xx_hal_msp.c hal_gpio.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/MT12864
    ../Drivers/MT12864/: stm32fx_display_hal.c stm32fx_display_hal.h display12864.c display12864.h
  group Drivers/Graphic
    ../Drivers/UniGraphic/: UnniRamFonts.h UnniRamGraphic.c UnniRamGraphic.h UnniRamFonts.c UnniRamGraphicUIObjects.c UnniRamGraphicUIObjects.h
  group Drivers/GPIO
    ../Drivers/GPIO/: gpio.c gpio.h
  group Drivers/MENU
    ../Drivers/MENU/: bsc_controls.c bsc_tree_menu.c
  group Drivers/MENU/MainMenu
    ../Drivers/MENU/MenuItems/: main_menu.h Menu1_StartMenu.c main_menu.c Menu2_MainMenu.c Menu3_SignalSynth.c Menu4_SignalSynthGen1.c Menu5_SignalSynthGen2.c Menu6_PatternGenerator.c Menu17_SignalGenerator.c Menu_6_1 Square simple.c Menu_6_2 Square.c Menu_6_3 Phase simple.c Menu_6_4 Phase.c Menu_6_5 Sinus.c Menu_6_6 Triangle.c Menu_6_7 Multi Pulse.c Menu_6_8 Three Phase.c Menu_6_9 Square timer.c Menu_FrequencyMeter.c
  group Drivers/AD9850
    ../Drivers/AD9850/: ad9850.c ad9850.h
  group Drivers\PatternGenerator
    ../Drivers/PatternGenerator/: generator407.c generator407.h
  group Drivers\StandardSignalGenerator
    ../Drivers/StandardSignalGenerator/: gen_timers.c gen_timers.h
  group SimpleGenerator
    ../Drivers/PatternGenerator/SimpleGenerator/: SimpleGenerator.c SimpleGenerator.h
  group FrequencyMeter
    ../Drivers/FrequencyMeter/: counter.c counter.h
  group Flash
    ../Drivers/Gen_Flash/: gen_flash.c gen_flash.h
  group spi_eeprom
    ../Drivers/spi_eeprom/: spi_eeprom.c spi_eeprom.h
software components: CMSIS:CORE 5.6.0
